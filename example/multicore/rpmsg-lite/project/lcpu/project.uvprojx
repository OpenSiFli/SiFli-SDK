# Keil uVision project project.uvprojx, settings and files
target rt-thread (6140001::V6.14.1::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: main
  AfterMake: postbuild.bat !L
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: SIFLI_VERSION=33619975, __FILE__=__FILE_NAME__, USE_HAL_DRIVER, SOC_BF0_LCPU, ROM_ENABLED, ARM_MATH_LOOPUNROLL, SF32LB56X, SIFLI_BUILD="000000", RT_USING_ARM_LIBC
  c misc: -Wno-builtin-macro-redefined  -march=armv8-m.main+cdecp1
  c include: build_eh-lb563_v2_lcpu;..\..\..\..\..\rtos\rtthread\include;board;..\..\..\..\..\customer\boards\common;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\boards\include\config\sf32lb56x;..\..\..\..\..\customer\boards\eh-lb563_v2;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\boards\eh-lb56xu_v2;..\..\..\..\..\customer\boards\include;..\..\..\..\..\rtos\rtthread\bsp\sifli\drivers;..\..\..\..\..\rtos\rtthread\bsp\sifli\drivers\config\sf32lb56x;..\..\src\lcpu;..\..\src\common;..\..\..\..\..\drivers\cmsis\sf32lb56x;..\..\..\..\..\drivers\cmsis\Include;..\..\..\..\..\external\CMSIS\Include;..\..\..\..\..\drivers\Include;..\..\..\..\..\middleware\include;..\..\..\..\..\middleware\ipc_queue\common;..\..\..\..\..\middleware\ipc_queue\porting\os;..\..\..\..\..\middleware\ipc_queue\porting\os\rtthread;..\..\..\..\..\middleware\ipc_queue\porting\sf32lb56x;..\..\..\..\..\middleware\ipc_queue\porting\sf32lb56x\lcpu;..\..\..\..\..\middleware\sifli_lib\lib;..\..\..\..\..\middleware\include;..\..\..\..\..\rtos\os_adaptor\src;..\..\..\..\..\rtos\os_adaptor\inc;..\..\..\..\..\rtos\rtthread\libcpu\arm\Cortex-M33;..\..\..\..\..\rtos\rtthread\libcpu\arm\common;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\finsh;..\..\..\..\..\rtos\rtthread\components\libc\compilers\armlibc;..\..\..\..\..\rtos\rtthread\components\libc\compilers\common;..\..\..\..\..\rtos\rtthread\components\utilities\llt_mem;..\..\..\..\..\rtos\rtthread\components\utilities\ulog;..\..\..\..\..\rtos\rtthread\components\utilities\ulog\backend
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: build_eh-lb563_v2_lcpu/link.sct
  link misc: --cpu=Cortex-M33 --strict --scatter build_eh-lb563_v2_lcpu/link.sct --summary_stderr --info summarysizes --map --load_addr_map_info --xref --callgraph --symbols --info sizes --info totals --info unused --info veneers --any_contingency  --list build_eh-lb563_v2_lcpu/main.map  --symdefs=build_eh-lb563_v2_lcpu/main.symdefs  --libpath=C:/Keil_v5/ARM/ARMCLANG/lib --predefine="-DSF32LB56X" --predefine="-DSIFLI_VERSION=33619975" --predefine="-DUSE_HAL_DRIVER" --predefine="-DSOC_BF0_LCPU" --predefine="-DROM_ENABLED" --predefine="-DARM_MATH_LOOPUNROLL" --predefine="-DSF32LB56X" --predefine="-DSIFLI_BUILD="000000"" --predefine="-DRT_USING_ARM_LIBC"
  group Kernel
    ../../../../../rtos/rtthread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Drivers
    board/: board.c bf0_ap_hal_msp.c
    ../../../../../customer/boards/common/: flash.c
    ../../../../../customer/boards/eh-lb56xu_v2/: bsp_init.c bsp_lcd_tp.c bsp_pinmux.c bsp_power.c
    ../../../../../rtos/rtthread/bsp/sifli/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_spi_flash.c drv_spi_nand.c drv_sys_cfg.c drv_psram.c drv_mpi.c drv_common.c drv_dbg.c
  group App_main
    ../../src/lcpu/: main.c
  group CMSIS_BF0
    ../../../../../drivers/cmsis/sf32lb56x/: bf0_pin_const.c
    ../../../../../drivers/cmsis/sf32lb56x/Templates/: system_bf0_ap.c
    ../../../../../drivers/cmsis/sf32lb56x/Templates/arm/: startup_bf0_lcpu.S
  group BF0_HAL
    ../../../../../drivers/hal/: bf0_hal.c bf0_hal_adc.c bf0_hal_aes.c bf0_hal_audcodec.c bf0_hal_audprc.c bf0_hal_bleaon.c bf0_hal_busmon.c bf0_hal_cortex.c bf0_hal_crc.c bf0_hal_dma.c bf0_hal_dsi.c bf0_hal_efuse.c bf0_hal_epic.c bf0_hal_ext_dma.c bf0_hal_ezip.c bf0_hal_facc.c bf0_hal_fft.c bf0_hal_gpio.c bf0_hal_hcd.c bf0_hal_hlp.c bf0_hal_hpaon.c bf0_hal_i2c.c bf0_hal_i2s.c bf0_hal_lcdc.c bf0_hal_lcpu_config.c bf0_hal_lpaon.c bf0_hal_lpcomp.c bf0_hal_lptim.c bf0_hal_lrc_cal.c bf0_hal_mailbox.c bf0_hal_mpi.c bf0_hal_mpi_ex.c bf0_hal_mpi_psram.c bf0_hal_nn_acc.c bf0_hal_patch.c bf0_hal_pcd.c bf0_hal_pdm.c bf0_hal_pinmux.c bf0_hal_pmu.c bf0_hal_psram.c bf0_hal_ptc.c bf0_hal_rcc.c bf0_hal_rng.c bf0_hal_rtc.c bf0_hal_sd_ex.c bf0_hal_sdadc.c bf0_hal_sdhci.c bf0_hal_sdmmc.c bf0_hal_secu.c bf0_hal_spi.c bf0_hal_tim.c bf0_hal_tim_ex.c bf0_hal_tsen.c bf0_hal_uart.c bf0_hal_wdt.c bf0_sys_cfg.c flash_table.c nand_table.c sifli_bbm.c
  group BF0_HAL
    ../../../../../drivers/hal/: sifli_rom_56x.sym
  group middleware
    ../../../../../middleware/ipc_queue/common/: circular_buf.c ipc_hw.c ipc_queue.c
    ../../../../../middleware/ipc_queue/porting/sf32lb56x/lcpu/: ipc_hw_port.c
  group sifli_lib
    ../../../../../middleware/sifli_lib/lib/: dummy.c
  group sifli_lib
    ../../../../../middleware/sifli_lib/lib/: sifli_lib_l_rvds.lib
  group m_system
    ../../../../../middleware/system/: bf0_common.c
  group os_adapter
    ../../../../../rtos/os_adaptor/src/: os_adaptor_rtthread.c
  group CORTEX-M33
    ../../../../../rtos/rtthread/libcpu/arm/Cortex-M33/: cpuport.c context_rvds.S
    ../../../../../rtos/rtthread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../../../../rtos/rtthread/components/drivers/hwmailbox/: hwmailbox.c
    ../../../../../rtos/rtthread/components/drivers/hwtimer/: hwtimer.c
    ../../../../../rtos/rtthread/components/drivers/misc/: pin.c
    ../../../../../rtos/rtthread/components/drivers/serial/: serial.c
    ../../../../../rtos/rtthread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../../../rtos/rtthread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../../../../rtos/rtthread/components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c time.c
    ../../../../../rtos/rtthread/components/libc/compilers/common/: gmtime_r.c
  group Utilities
    ../../../../../rtos/rtthread/components/utilities/llt_mem/: llt_mem.c
    ../../../../../rtos/rtthread/components/utilities/ulog/: ulog.c
    ../../../../../rtos/rtthread/components/utilities/ulog/backend/: console_be.c
