# Keil uVision project project.uvprojx, settings and files
target flash1 (6140001::V6.14.1::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: ftab +hex
  AfterMake: fromelf --bin !L --output ftab_qspi1.bin
  AfterMake: fromelf --i32 !L --output ftab_qspi1.hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: SF32LB56X, SOC_BF0_HCPU, USE_HAL_DRIVER, ARM_MATH_LOOPUNROLL
  c misc: -march=armv8-m.main+cdecp1
  c include: .;..\..\..\rtos\rtthread\include;board;board\ports;..\..\..\drivers\boards\include;..\..\..\rtos\rtthread\bsp\sifli\drivers;..\..\..\rtos\rtthread\bsp\sifli\drivers\config;..\..\..\rtos\rtthread\bsp\sifli\drivers\config\sf32lb56x;..\..\..\applications;.;..\..\..\drivers\cmsis\sf32lb56x;..\..\..\drivers\cmsis\Include;..\..\..\external\CMSIS\Include;..\..\..\drivers\Include;..\..\..\external\mbedtls\include;..\..\..\middleware\data_bus;.;..\..\..\middleware\include;..\..\..\rtos\rtthread\libcpu\arm\Cortex-M33;..\..\..\rtos\rtthread\libcpu\arm\common;..\..\..\rtos\rtthread\components\drivers\include;..\..\..\rtos\rtthread\components\drivers\include;..\..\..\rtos\rtthread\components\finsh;..\..\..\middleware\dfu;..\..\..\drivers\cmsis\sf32lb56x
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\board\linker_scripts\ftab.sct
  link misc: --symdefs  @L.sym  --cpu=Cortex-M33 --strict --scatter ./board/linker_scripts/ftab.sct --summary_stderr --info summarysizes --map --load_addr_map_info --xref --callgraph --symbols --info sizes --info totals --info unused --info veneers  --list build/bf0_ap.map  --libpath=C:/Keil_v5/ARM/ARMCLANG/lib
  group Applications
    ./: ftab.c
target flash5 (6140001::V6.14.1::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: ftab +hex
  AfterMake: fromelf --bin !L --output ftab_qspi5.bin
  AfterMake: fromelf --i32 !L --output ftab_qspi5.hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: SF32LB56X, SOC_BF0_HCPU, USE_HAL_DRIVER, ARM_MATH_LOOPUNROLL,QSPI5
  c misc: -march=armv8-m.main+cdecp1
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\board\linker_scripts\ftab.sct
  link misc: --symdefs  @L.sym  --cpu=Cortex-M33 --predefine="-DQSPI2" --strict --scatter ./board/linker_scripts/ftab.sct --summary_stderr --info summarysizes --map --load_addr_map_info --xref --callgraph --symbols --info sizes --info totals --info unused --info veneers  --list build/bf0_ap.map  --libpath=C:/Keil_v5/ARM/ARMCLANG/lib
